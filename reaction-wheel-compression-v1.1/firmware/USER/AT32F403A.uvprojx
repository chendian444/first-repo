# Keil uVision project AT32F403A.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F403ARCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403A
  AfterMake: fromelf --bin !L --output "../bin/AT32_balanced-cube.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403ARCT7,HEXT_VALUE=25000000
  c include: ..\AT32F403A_StdPeriph_Driver\inc;..\USER;..\UserFile;..\cmsis\core_support;..\cmsis\device_support;..\cmsis\device_support\startup
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../UserFile/: app.h
    ./: main.c at32f403a_407_clock.c at32f403a_407_int.c
    ../cmsis/device_support/: system_at32f403a_407.c
  group startup
    ../cmsis/device_support/startup/: startup_at32f403a_407.s
  group AT32F403A_StdPeriph_Driver
    ../AT32F403A_StdPeriph_Driver/src/: at32f403a_407_gpio.c at32f403a_407_crm.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_spi.c at32f403a_407_usart.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_adc.c at32f403a_407_can.c at32f403a_407_i2c.c
  group UserFile
    ../UserFile/: usart.c Debug.c timer.c adc.c Encoder.c AHRS.c key.c Calibration.c app.c Gpio_Config.c WS2812.c Control.c delay.c flash.c MPU6500.c lcd.c lcd_init.c AT32F403A_FOC_LIB.lib RcData.c
  group readme
    ../: readme.md
  group WheelTelemetry
    ../UserFile/: WheelCodec.c WheelTelemetry.c
